FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://powersave.cfg"
